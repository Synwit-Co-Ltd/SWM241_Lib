# Keil uVision project SimplCRC.uvprojx, settings and files
target SWM241 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM241xB Synwit
  pack: Synwit.SWM32_New.0.0.7
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SimplCRC
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: ..\..\SWM241_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM241_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM241_StdPeriph_Driver\CSL\SWM241_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ../../SWM241_StdPeriph_Driver/CSL/SWM241_StdPeriph_Driver/: SWM241_adc.c SWM241_exti.c SWM241_gpio.c SWM241_i2c.c SWM241_pwm.c SWM241_timr.c SWM241_uart.c SWM241_wdt.c SWM241_div.c SWM241_dma.c SWM241_flash.c SWM241_port.c SWM241_spi.c SWM241_rtc.c SWM241_crc.c SWM241_safety.c SWM241_sleep.c SWM241_can.c SWM241_slcd.c SWM241_sled.c
  group CSL\CMSIS
    ../../SWM241_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM241.c
    ../../SWM241_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM241.s
