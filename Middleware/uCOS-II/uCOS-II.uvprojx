# Keil uVision project uCOS-II.uvprojx, settings and files
target SWM241 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM241xB Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uCOS-II
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=1
  c include: ..\..\SWM241_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM241_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM241_StdPeriph_Driver\CSL\SWM241_StdPeriph_Driver;.\APP\uCOS;.\APP\uCOS\port_MDK;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./app/: main.c
  group uCOS
    ./APP/uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS\Port
    ./APP/uCOS/port_MDK/: os_cpu_c.c os_cpu_a.asm os_dbg.c
  group CSL\StdPD
    ../../SWM241_StdPeriph_Driver/CSL/SWM241_StdPeriph_Driver/: SWM241_adc.c SWM241_exti.c SWM241_gpio.c SWM241_i2c.c SWM241_pwm.c SWM241_timr.c SWM241_uart.c SWM241_wdt.c SWM241_div.c SWM241_dma.c SWM241_flash.c SWM241_port.c SWM241_spi.c SWM241_rtc.c
  group CSL\CMSIS
    ../../SWM241_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM241.c
    ../../SWM241_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM241.s
