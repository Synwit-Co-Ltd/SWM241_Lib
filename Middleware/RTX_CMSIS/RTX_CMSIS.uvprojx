# Keil uVision project RTX_CMSIS.uvprojx, settings and files
target SWM241 (ARM-ADS)
  device: SWM241xB Synwit
  pack: Synwit.SWM32_DFP.2.0.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RTX_CMSIS
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: ..\..\SWM241_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM241_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM241_StdPeriph_Driver\CSL\SWM241_StdPeriph_Driver;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./APP/: main.c
  group CSL\StdPD
    ../../SWM241_StdPeriph_Driver/CSL/SWM241_StdPeriph_Driver/: SWM241_adc.c SWM241_can.c SWM241_crc.c SWM241_div.c SWM241_dma.c SWM241_exti.c SWM241_flash.c SWM241_gpio.c SWM241_i2c.c SWM241_port.c SWM241_pwm.c SWM241_rtc.c SWM241_safety.c SWM241_slcd.c SWM241_sled.c SWM241_sleep.c SWM241_spi.c SWM241_timr.c SWM241_uart.c SWM241_wdt.c
  group CSL\CMSIS
    ../../SWM241_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM241.c
    ../../SWM241_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM241.s
